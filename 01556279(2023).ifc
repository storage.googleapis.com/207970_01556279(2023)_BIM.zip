Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-02-07T17:04:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 07 17:04:55 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\619336c7-72e8-46ce-b46f-fec3da8e1044\ced9bed3-c900-4684-812f-01d06e6c475e\ifc * Database version: 5507 * Database creation date: Wed Feb 07 17:04:29 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 07 17:04:30 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 07 17:04:30 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 01556279 Washbasin faucet, Bluetooth, 01556279(2023):01556279 Washbasin faucet, Bluetooth:429611
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 190.906 mm; NominalHeight: 162.33 mm; NominalWidth: 195.515 mm
Type - Electrical - Bluetooth: 5.x (D060576); Operating Voltage: 0 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 01556279(2023); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 4057304020490; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; Sales Package dimensions (LxWxH): 278 x 218 x 202; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/01556279; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL WEEE: http://static.hansa.com/WEEE/01556279
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/01556279; 3D View: https://static.hansa.com/AR/01556279; Catalog Drawing URL: http://static.hansa.com/catdrw/01556279; Dimension Drawing URL: http://static.hansa.com/dimdrw/01556279; FDV Document URL: http://www.hansa.com/datasheet/01556279/en/fdv; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/01556279; Interactive AR View URL: https://static.hansa.com/AR/01556279; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands; Mobile Product Information URL: http://mpi.hansa.com/01556279; Model: 01556279 Washbasin faucet, Bluetooth; Name_en: 01556279 Washbasin faucet, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 01556279; Product Family: HANSACLINICA Digital+; Product Image URL: http://static.hansa.com/image/01556279; Product URL: http://static.hansa.com/01556279; Short Marketing: This faucet is designed for Health care usage. With its Low lead water ways and a well designed body that is easy to clean while the long lever makes it easy and intuitive to operate. With our latest technology it is possible to connect this faucet to the Digital water management service. The online service helps monitoring of the usage to prevent stagnation and to follow-up the temperatures in the piping. Measuring technology inside the faucet body is self-powered by water, no batteries needed. Clever design with a world of information inside.; Technical DataSheet URL: http://www.hansa.com/datasheet/01556279/en; Type Name: 01556279 Washbasin faucet, Bluetooth; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Composite; Aerator: Laminar stream; Connection: Eccentric coupling(s); Installation Type: Wall mounted; Lever Handle: Pin shape; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Spout Type: Swivel spout; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 01556279(2023); Features: Single-lever;Self-powered;Bluetooth®;Lead free; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 01556279; Name: 01556279 Washbasin faucet, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 196x190x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 01556279 Washbasin faucet, Bluetooth; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 01556279; Manufacturer: HANSA
Pset_ProductRequirements - Name: 01556279 Washbasin faucet, Bluetooth; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.102055 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00607131 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 01556279(2023): 01556279 Washbasin faucet, Bluetooth; Family and Type: 01556279(2023): 01556279 Washbasin faucet, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 01556279(2023): 01556279 Washbasin faucet, Bluetooth; Type Id: 01556279(2023): 01556279 Washbasin faucet, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
